# Keil uVision project SmartHome.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CModel
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\st_Periph_driver\inc;.\User;.\GeneralFunction;.\GeneralFunction\Delay;.\GeneralFunction\LCD;.\GeneralFunction\Usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: Main.c
  group CMSIS
    ../../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Std_periph_driver
    ./st_Periph_driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_tim.c
  group General_Function
    ./GeneralFunction/Delay/: delay.c
    ./GeneralFunction/Usart/: usart.c
    ./GeneralFunction/: smarthome.c
